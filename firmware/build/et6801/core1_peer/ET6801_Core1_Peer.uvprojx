# Keil uVision project ET6801_Core1_Peer.uvprojx, settings and files
target ET6801_CORE1_ITCM_PEER (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: et6801_core1_itcm_peer +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ET6801,CPU1_CODE,ITCM_CODE,FPGA_VERSION,ET_TARGET_FPGA,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: ..\..\..\chips\et6801\core1_peer\include;..\..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\..\chips\et6801\sdk\ET6x_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\chips\et6801\core1_peer\linker\link_core1_itcm.sct
  group Core1_Peer
    ../../../chips/et6801/core1_peer/include/: et_core1_peer_shared.h
    ../../../chips/et6801/core1_peer/src/: et_core1_peer_main.c
  group Chip_Startup
    ../../../chips/et6801/sdk/CMSIS/Device/Source/arm/: startup_et6801.s
  group Chip_System
    ../../../chips/et6801/sdk/CMSIS/Device/Source/: system_et6x.c
  group Chip_Drivers
    ../../../chips/et6801/sdk/ET6x_Driver/Src/: et6x_dualcore.c et6x_spinlock.c
target ET6801_CORE1_PFLASH1_PEER (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08080000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: et6801_core1_pflash1_peer +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: ET6801,CPU1_CODE,FLASH_CODE,FPGA_VERSION,ET_TARGET_SILICON,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\chips\et6801\core1_peer\linker\link_core1_pflash1.sct

# Keil uVision project ET6801_Automated_Test.uvprojx, settings and files
target ET6801_FPGA_ITCM (6160000::V6.16::ARMCLANG)
  device: ET6801 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: et6801_test_fpga +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ET6801,CPU0_CODE,ITCM_CODE,FPGA_VERSION,ET_TARGET_FPGA,ET_AUTO_TEST_FRAMEWORK,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: ..\..\application\include;..\..\boards\include;..\..\framework\include;..\..\services\include;..\..\wrap\include;..\..\chips\et6801\config;..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\chips\et6801\sdk\ET6x_Driver\Inc;..\..\boards\et6801_fpga
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\chips\et6801\linker\link_itcm.sct
  group Application
    ../../application/src/: main.c et_control_uart.c et_service_manifest.c
  group Framework
    ../../framework/src/: et_frame.c et_irq_manager.c et_message.c et_protocol.c et_ring_buffer.c et_runtime.c et_service_router.c
  group Services
    ../../services/src/: et_services.c et_framework_service.c et_resource_service.c et_crg_service.c et_cpu_service.c et_sysctrl_service.c et_uart_service.c et_dma_service.c et_crc_service.c et_aes_service.c et_fmac_service.c et_cordic_service.c et_wdg_service.c et_stimer_service.c et_spinlock_service.c et_ipcm_service.c et_syscnt_service.c et_spi_service.c et_gpio_service.c et_can_service.c
  group Wrap
    ../../wrap/src/: et_resource_wrap.c et_system_wrap.c et_cortex_wrap.c et_crg_wrap.c et_cpu_wrap.c et_sysctrl_wrap.c et_irq_wrap.c et_gpio_wrap.c et_uart_wrap.c et_dma_wrap.c et_crc_wrap.c et_aes_wrap.c et_fmac_wrap.c et_cordic_wrap.c et_wdg_wrap.c et_stimer_wrap.c et_spinlock_wrap.c et_ipcm_wrap.c et_syscnt_wrap.c et_spi_wrap.c et_can_wrap.c
  group Chip_Startup
    ../../chips/et6801/sdk/CMSIS/Device/Source/arm/: startup_et6801.s
  group Chip_System
    ../../chips/et6801/sdk/CMSIS/Device/Source/: system_et6x.c
  group Chip_Drivers
    ../../chips/et6801/sdk/ET6x_Driver/Src/: et6x_ahbdma.c et6x_aes.c et6x_cortex.c et6x_crg.c et6x_cpu.c et6x_dualcore.c et6x_crc.c et6x_fmac.c et6x_cordic.c et6x_wdg.c et6x_stimer.c et6x_spinlock.c et6x_ipcm.c et6x_xbar.c et6x_gpio.c et6x_spi.c et6x_can.c et6x_interrupt.c et6x_sysctrl.c et6x_uart.c
  group Board
    ../../boards/et6801_fpga/: et_board_config.h
    ../../boards/et6801_silicon/: et_board_config.h
  group Manual_Diagnostics
    ../../manual_tests/et6801/include/: et_manual_test.h et_manual_test_config.h et_manual_test_internal.h
    ../../manual_tests/et6801/src/: et_manual_test.c et_manual_uart_test.c et_manual_crc_test.c et_manual_aes_test.c et_manual_cordic_test.c et_manual_crg_test.c et_manual_fmac_test.c et_manual_stimer_test.c et_manual_wdg_test.c et_manual_dualcore_test.c
target ET6801_SILICON_FLASH (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x20400000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: et6801_test_silicon +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: ET6801,CPU0_CODE,FLASH_CODE,FPGA_VERSION,ET_TARGET_SILICON,ET_AUTO_TEST_FRAMEWORK,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: ..\..\application\include;..\..\boards\include;..\..\framework\include;..\..\services\include;..\..\wrap\include;..\..\chips\et6801\config;..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\chips\et6801\sdk\ET6x_Driver\Inc;..\..\boards\et6801_silicon
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\chips\et6801\linker\link_pflash.sct
target ET6801_FPGA_MANUAL_FLASH (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: as above
  output: et6801_manual_uart_crc_fpga_flash +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: as above
  c define: ET6801,CPU0_CODE,FLASH_CODE,FPGA_VERSION,ET_TARGET_FPGA,ET_MANUAL_TEST_ENABLE,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: ..\..\application\include;..\..\boards\include;..\..\framework\include;..\..\services\include;..\..\wrap\include;..\..\chips\et6801\config;..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\chips\et6801\sdk\ET6x_Driver\Inc;..\..\boards\et6801_fpga;..\..\manual_tests\et6801\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\chips\et6801\linker\link_pflash.sct
target ET6801_FPGA_CORE1_SMOKE_ITCM (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: et6801_core1_launcher_itcm +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ET6801,CPU0_CODE,ITCM_CODE,FPGA_VERSION,ET_TARGET_FPGA,ET_MANUAL_TEST_ENABLE,ET_MANUAL_CORE1_SMOKE_ONLY,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: ..\..\application\include;..\..\boards\include;..\..\framework\include;..\..\services\include;..\..\wrap\include;..\..\chips\et6801\config;..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\chips\et6801\sdk\ET6x_Driver\Inc;..\..\boards\et6801_fpga;..\..\manual_tests\et6801\include;..\..\chips\et6801\core1_peer\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\chips\et6801\core1_peer\linker\link_core0_launcher_itcm.sct
target ET6801_SILICON_CORE1_LAUNCHER_FLASH (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: as above
  output: et6801_core1_launcher_flash +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: as above
  c define: ET6801,CPU0_CODE,FLASH_CODE,FPGA_VERSION,ET_TARGET_SILICON,ET_MANUAL_TEST_ENABLE,ET_MANUAL_CORE1_SMOKE_ONLY,ET_ENABLE_TEST_DRIVER_EXTENSIONS
  c include: ..\..\application\include;..\..\boards\include;..\..\framework\include;..\..\services\include;..\..\wrap\include;..\..\chips\et6801\config;..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\chips\et6801\sdk\ET6x_Driver\Inc;..\..\boards\et6801_silicon;..\..\manual_tests\et6801\include;..\..\chips\et6801\core1_peer\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\chips\et6801\linker\link_pflash.sct

# Keil uVision project base.uvprojx, settings and files
target ET6801_FPGA_ITCM (6160000::V6.16::ARMCLANG)
  device: ET6801 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: et6801_test_fpga +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ET6801,CPU0_CODE,ITCM_CODE,FPGA_VERSION,ET_TARGET_FPGA,ET_AUTO_TEST_FRAMEWORK
  c include: ..\..\application\include;..\..\framework\include;..\..\testcases\include;..\..\wrap\include;..\..\chips\et6801\config;..\..\chips\et6801\sdk\CMSIS\Core\Include;..\..\chips\et6801\sdk\CMSIS\Device\Include;..\..\chips\et6801\sdk\ET6x_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\chips\et6801\linker\link_itcm.sct
  group Application
    ../../application/src/: main.c et_control_uart.c
  group Framework
    ../../framework/src/: et_case_manager.c et_command.c et_frame.c et_ip_registry.c et_irq_manager.c et_protocol.c et_ring_buffer.c et_runtime.c
  group Wrap
    ../../wrap/src/: et_system_wrap.c et_irq_wrap.c et_gpio_wrap.c et_uart_wrap.c
  group TestCases
    ../../testcases/src/: et_testcases.c
  group Chip_Startup
    ../../chips/et6801/sdk/CMSIS/Device/Source/arm/: startup_et6801.s
  group Chip_System
    ../../chips/et6801/sdk/CMSIS/Device/Source/: system_et6x.c
  group Chip_Drivers
    ../../chips/et6801/sdk/ET6x_Driver/Src/: et6x_cortex.c et6x_crg.c et6x_gpio.c et6x_interrupt.c et6x_uart.c
target ET6801_SILICON_FLASH (6160000::V6.16::ARMCLANG)
  device: ET6801 ETMCU
  pack: ETMCU.ET6801_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x20400000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: et6801_test_silicon +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: ET6801,CPU0_CODE,FLASH_CODE,FPGA_VERSION,ET_TARGET_SILICON,ET_AUTO_TEST_FRAMEWORK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\chips\et6801\linker\link_pflash.sct
